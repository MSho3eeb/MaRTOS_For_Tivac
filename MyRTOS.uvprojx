# Keil uVision project MyRTOS.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Cortex_OS_Porting.c Cortex_OS_Porting.h main.c MaRTOS.c MaRTOS.h MaRTOS_Config.h RTOS_FIFO.c RTOS_FIFO.h Scheduler.c Scheduler.h SchedulerTypes.h tm4c123gh6pm.h types.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
